# Repository c0pperdragon/D-Video

File README.md:

# D-Video

A system to pump digital video out of vintage home computers.

While there are many mods available to make the video quality of old home computers and consoles
look better on modern displays, most of them are using analog technology (S-Video or RGB or such).
Analog signals are always prone to distortion and some rest of static noise always remains.

To overcome this problem and to get pixel-perfect quality identical to what an emulator could do, 
I have created a system that extracts the video information directly at the pins of the video chip
and transfer this signals to a converter that can generate crisp clear HDMI from it.
Clearly for every computer model there is a different way how to extract video information from the
video chip, and so the converter device must support all different signal types needed. 

That is done by using an FPGA that can be programmed to the meet the specific requirements 
of the system. For this I have designed my on FPGA board which I called the 
D-Video board that is based on a MAX 10 which is a pretty cheap device in comparison
with more powerful chips. With 8K elements and about 380kBit of memory, it just
covers what I need for my projects.

To feed the data into this FPGA, an additional modification board for each computer is needed
that converts the voltages from the pins to 3.3V levels. 

Currently supported devices:
	Atari 800 XL PAL   (probably every 8-bit Atari PAL)

## KiCad design dvideoboard/rev2/dvideoboard.kicad_pcb

File dvideoboard/README.md:

# D-Video board

This is the heart of the whole project. A multi-purpose FPGA board with 
a HDMI transmitter that is capable of generating full HD.
In my research if found many cheap FPGA boards, but 
only one was able to actually generate full HD images (the Cyclone 5 GX Starter Kit),
and this was not actually that cheap. Also it was a full-blown experimental board
with tons of features that would never fit into a vintage computer.
So I decided to create my own bare-bone FPGA board with an HTMI transmitter.

Using a device of the MAX 10 series seemed to be quite the right choice, mainly because
it is available as a TQFP package which can still be somehow handled by a hobbyist
(still, it took some attempts until I actually managed so assemble a working board).

Next to the MAX 10 is a ADV7513 HDMI transmitter that takes care of the real 
high-frequency signal generation. The data path from the FPGA to the transmitter
is is very short and the parallel 145Mhz signals seem to be running just fine.

The board has a 31-bin GPIO connector for any sort of digital communication, its main
purpose for my general project is to sniff the various pins in a vintage computer
system to compute a digital live image of the video output.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C32, C33, C34, C35, C36, C37, C39, C40, C41, C43: 100nF; C_0603_HandSoldering
C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C38: 10uF; C_0805_HandSoldering
IC1, IC2: AP3417C; TSOT-23-5_HandSoldering
L1, L2, L3, L4, L6, L7, L8: 10uH; C_0805_HandSoldering
L5, L9: 2.2uH; C_0805_HandSoldering
P1: CONN_02X16; Pin_Header_Straight_2x16_Pitch2.54mm
P2: JTAG; Pin_Header_Angled_2x05_Pitch2.54mm
P3: POWER; Pin_Header_Straight_1x02_Pitch2.54mm
P4: HDMI-A; FCI_10029449-11-5B13-5DRLF
R1, R2, R3, R4, R5, R6, R7, R13: 10k; R_0805_HandSoldering
R8: 450k 1%; R_0805_HandSoldering
R9, R18: 100k 1%; R_0805_HandSoldering
R10: 887 1%; R_0805_HandSoldering
R11, R12, R14, R15: 2K; R_0805_HandSoldering
R17: 200k 1%; R_0805_HandSoldering
U1: 10M08SCE144C8G; QFP_144_GND
U2: LFSPXO025560; Crystal_SMD_EuroQuartz_MT-4pin_3.2x2.5mm_HandSoldering
U3: ADV7513; LQFP-64-1EP_10x10mm_Pitch0.5mm

Connections:
+5V: C25.1, C27.2, C38.2, IC1.1 (EN), IC1.4 (VIN), IC2.1 (EN), IC2.4 (VIN), P3.2, R14.2, R15.2
/1V8: C30.2, L6.2, L7.2, L8.2, L9.2, R17.1
/1V8A: C28.1, C32.1, C33.1, C36.1, C39.1, L6.1, U3.1 (DVDD), U3.11 (DVDD), U3.31 (DVDD), U3.51 (DVDD)
/1V8B: C29.1, C34.1, C37.1, C40.1, L7.1, U3.15 (AVDD), U3.19 (AVDD), U3.25 (AVDD)
/1V8C: C31.1, C41.2, L8.1, U3.12 (PVDD), U3.13 (BGVDD)
/3V3: C24.2, L1.2, L2.2, L3.2, L4.2, L5.2, R8.1
/3V3A: C21.1, L1.1, P2.4, R4.2, R5.2, R6.2
/3V3B: C1.1, C3.1, C5.1, C7.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C22.1, C43.1, L2.1, R1.2, R2.2, U1.1 (VCC_ONE), U1.9 (VCCIO1A), U1.23 (VCCIO1B), U1.31 (VCCIO2), U1.36 (VCC_ONE), U1.37 (VCC_ONE), U1.40 (VCCIO3), U1.49 (VCCIO3), U1.51 (VCC_ONE), U1.67 (VCCIO4), U1.72 (VCC_ONE), U1.73 (VCC_ONE), U1.82 (VCCIO5), U1.94 (VCCIO6), U1.103 (VCCIO6), U1.108 (VCC_ONE), U1.109 (VCC_ONE), U1.115 (VCC_ONE), U1.117 (VCCIO7), U1.121 (DEV_CLRn), U1.122 (DEV_OE), U1.128 (VCCIO8), U1.129 (nCONFIG), U1.139 (VCCIO8), U1.144 (VCC_ONE)
/3V3C: C2.1, C4.1, C6.1, C8.1, C23.1, L3.1, U1.2 (VCC_A6), U1.5 (VCC_A3), U1.34 (VCCA2), U1.35 (VCCA1), U1.71 (VCCA5), U1.107 (VCCA3), U1.143 (VCCA4)
/3V3D: C20.1, C26.1, C35.2, L4.1, R11.2, R12.2, U2.1, U2.4, U3.29 (DVDD_3V)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C27.1, C28.2, C29.2, C30.1, C31.2, C32.2, C33.2, C34.2, C35.1, C36.2, C37.2, C38.1, C39.2, C40.2, C41.1, C43.2, IC1.2 (GND), IC2.2 (GND), P1.1, P2.2, P2.10, P3.1, P4.2 (TMDS_D2S), P4.5 (TMDS_D1S), P4.8 (TMDS_D0S), P4.11 (TMDS_CLKS), P4.17 (GND), P4.SHLD, R3.2, R7.1, R9.1, R10.1, R13.1, R18.1, U1.3 (GND), U1.4 (GND), U1.42 (GND), U1.53 (GND), U1.63 (GND), U1.68 (GND), U1.83 (GND), U1.95 (GND), U1.104 (GND), U1.116 (GND), U1.125 (GND), U1.133 (GND), U1.137 (GND), U1.142 (GND), U1.145 (GND), U2.2, U3.4 (MCLK), U3.5 (I2SO), U3.6 (I2S1), U3.7 (I2S2)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
unnamed: IC1.3 (LX), L5.1
unnamed: IC1.5 (FB), R8.2, R9.2
unnamed: IC2.3 (LX), L9.1
unnamed: IC2.5 (FB), R17.2, R18.2
unnamed: P1.2, U1.26 (IO_2/CLK0n)
unnamed: P1.3, U1.24 (IO_1B)
unnamed: P1.4, U1.25 (IO_1B)
unnamed: P1.5, U1.21 (IO_1B)
unnamed: P1.6, U1.22 (IO_1B)
unnamed: P1.7, U1.14 (IO_1A)
unnamed: P1.8, U1.17 (IO_1B)
unnamed: P1.9, U1.12 (IO_1A)
unnamed: P1.10, U1.13 (IO_1A)
unnamed: P1.11, U1.10 (IO_1A)
unnamed: P1.12, U1.11 (IO_1A)
unnamed: P1.13, U1.7 (IO_1A)
unnamed: P1.14, U1.8 (IO_1A)
unnamed: P1.15, U1.141 (IO_8)
unnamed: P1.16, U1.6 (IO_1A)
unnamed: P1.17, U1.135 (IO_8)
unnamed: P1.18, U1.140 (IO_8)
unnamed: P1.19, U1.131 (IO_8)
unnamed: P1.20, U1.132 (IO_8)
unnamed: P1.21, U1.127 (IO_8)
unnamed: P1.22, U1.130 (IO_8)
unnamed: P1.23, U1.123 (IO_8)
unnamed: P1.24, U1.124 (IO_8)
unnamed: P1.25, U1.119 (IO_7)
unnamed: P1.26, U1.120 (IO_8)
unnamed: P1.27, U1.114 (IO_7)
unnamed: P1.28, U1.118 (IO_7)
unnamed: P1.29, U1.112 (IO_7)
unnamed: P1.30, U1.113 (IO_7)
unnamed: P1.31, U1.110 (IO_7)
unnamed: P1.32, U1.111 (IO_7)
unnamed: P2.1, R7.2, U1.18 (TCK)
unnamed: P2.3, U1.20 (TDO)
unnamed: P2.5, R5.1, U1.16 (TMS)
unnamed: P2.9, R6.1, U1.19 (TDI)
unnamed: P4.1 (TMDS_D2+), U3.27 (TX2+)
unnamed: P4.3 (TMDS_D2-), U3.26 (TX2-)
unnamed: P4.4 (TMDS_D1+), U3.24 (TX1+)
unnamed: P4.6 (TMDS_D1-), U3.23 (TX1-)
unnamed: P4.7 (TMDS_D0+), U3.21 (TX0+)
unnamed: P4.9 (TMDS_D0-), U3.20 (TX0-)
unnamed: P4.10 (TMDS_CLK+), U3.18 (TXC+)
unnamed: P4.12 (TMDS_CLK-), U3.17 (TXC-)
unnamed: P4.15 (DDC_CLK), R15.1, U3.33 (DDCSCL)
unnamed: P4.16 (DDC_DAT), R14.1, U3.34 (DDCSDA)
unnamed: P4.19 (HPDET), R13.2, U3.16 (HPD)
unnamed: R1.1, U1.136 (nSTATUS)
unnamed: R2.1, U1.138 (CONF_DONE)
unnamed: R3.1, U1.126 (CONFIG_SEL)
unnamed: R4.1, U1.15 (JTAGEN)
unnamed: R10.2, U3.14 (R_EXT)
unnamed: R11.1, U1.70 (IO_4), U3.35 (SCL)
unnamed: R12.1, U1.69 (IO_4), U3.36 (SDA)
unnamed: U1.27 (IO_2/CLK0p), U3.3 (SPDIF)
unnamed: U1.28 (IO_2/CLK1n), U3.2 (VSYNC)
unnamed: U1.29 (IO_2/CLK1p), U3.64 (HSYNC)
unnamed: U1.30 (IO_2), U3.63 (DE)
unnamed: U1.32 (IO_2/PLL_L_CLKOUTn), U3.62 (D0)
unnamed: U1.33 (IO_2/PLL_L_CLKOUTp_), U3.61 (D1)
unnamed: U1.38 (IO_3), U3.60 (D2)
unnamed: U1.39 (IO_3), U3.59 (D3)
unnamed: U1.41 (IO_3), U3.58 (D4)
unnamed: U1.43 (IO_3), U3.57 (D5)
unnamed: U1.44 (IO_3), U3.56 (D6)
unnamed: U1.45 (IO_3), U3.55 (D7)
unnamed: U1.46 (IO_3), U3.54 (D8)
unnamed: U1.47 (IO_3), U3.53 (CLK)
unnamed: U1.48 (IO_3), U3.52 (D9)
unnamed: U1.50 (IO_3), U3.50 (D10)
unnamed: U1.52 (IO_3), U3.49 (D11)
unnamed: U1.54 (IO_3), U3.48 (D12)
unnamed: U1.55 (IO_3), U3.47 (D13)
unnamed: U1.56 (IO_3), U3.46 (D14)
unnamed: U1.57 (IO_3), U3.45 (D15)
unnamed: U1.58 (IO_3), U3.44 (D16)
unnamed: U1.59 (IO_3), U3.43 (D17)
unnamed: U1.60 (IO_3), U3.42 (D18)
unnamed: U1.61 (IO_4), U3.41 (D19)
unnamed: U1.62 (IO_4), U3.40 (D20)
unnamed: U1.64 (IO_4), U3.39 (D21)
unnamed: U1.65 (IO_4), U3.38 (D22)
unnamed: U1.66 (IO_4), U3.37 (D23)
unnamed: U1.88 (IO_6/CLK2p), U2.3

Board: 2 copper layers, 61.0 x 43.2 mm, 77 parts (46 on the bottom side), 98 nets.

## KiCad design dvideoboard/dvideoboard.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C9, C11, C12: 10uF; C_0805_HandSoldering
C7: 47u; C_1206_HandSoldering
C8, C10: 4.7u; C_0805_HandSoldering
C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43: 100nF; C_0805_HandSoldering
D1, D2: LED; LED_0805
F1: 0ZCK0050AF2E; C_0805_HandSoldering
IC1, IC2, IC3, IC4: SN74LVC245APWR; TSSOP-20_4.4x6.5mm_Pitch0.65mm
IC5, IC6: AP3417C; TSOT-23-5_HandSoldering
L1, L2, L3, L4, L5, L6, L7: 10uH; C_0805_HandSoldering
L8, L9: 2.2uH; C_0805_HandSoldering
P1: CONN_02X16; Pin_Header_Straight_2x16_Pitch2.54mm
P2: POWER; Pin_Header_Straight_1x02_Pitch2.54mm
P3: JTAG; Pin_Header_Straight_2x05_Pitch2.54mm
P4: HDMI-A; FCI_10029449-11-5B13-5DRLF
P5: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
R1, R16: 1K; R_0805_HandSoldering
R2, R3, R4, R5, R6, R7, R8, R12: 10k; R_0805_HandSoldering
R9: 887; R_0805_HandSoldering
R10, R11, R13, R14, R15: 2K; R_0805_HandSoldering
R17: 450k; R_0805_HandSoldering
R18, R20: 100k; R_0805_HandSoldering
R19: 200k; R_0805_HandSoldering
U1: 10M08SCE144C8G; QFP_144_GND
U2: ADV7513; LQFP-64-1EP_10x10mm_Pitch0.5mm
U3: TG2016SBN 20.0000M-TCGNNM3; Crystal_SMD_2016-4pin_2.0x1.6mm

Connections:
+5V: C7.1, C8.1, C10.1, F1.1, IC5.1 (EN), IC5.4 (VIN), IC6.1 (EN), IC6.4 (VIN), R13.1, R14.1
/1V8A: C5.2, C36.1, C37.1, C38.1, C39.1, L5.1, U2.1 (DVDD), U2.11 (DVDD), U2.31 (DVDD), U2.51 (DVDD)
/1V8B: C11.2, C41.1, C42.1, C43.1, L6.1, U2.15 (AVDD), U2.19 (AVDD), U2.25 (AVDD)
/1V8C: C12.2, C40.1, L7.1, U2.12 (PVDD), U2.13 (BGVDD)
/3V3A: C1.2, C13.1, C14.1, C15.1, C16.1, IC1.1 (DIR), IC1.20 (VCC), IC2.1 (DIR), IC2.20 (VCC), IC3.1 (DIR), IC3.20 (VCC), IC4.1 (DIR), IC4.20 (VCC), L1.1, P3.4, R3.2, R4.2, R5.2, U3.4 (VCC)
/3V3B: C2.2, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C35.1, L2.1, R6.1, R7.1, U1.1 (VCC_ONE), U1.9 (VCCIO1A), U1.23 (VCCIO1B), U1.31 (VCCIO2), U1.36 (VCC_ONE), U1.37 (VCC_ONE), U1.40 (VCCIO3), U1.49 (VCCIO3), U1.51 (VCC_ONE), U1.67 (VCCIO4), U1.72 (VCC_ONE), U1.73 (VCC_ONE), U1.82 (VCCIO5), U1.94 (VCCIO6), U1.103 (VCCIO6), U1.108 (VCC_ONE), U1.109 (VCC_ONE), U1.115 (VCC_ONE), U1.117 (VCCIO7), U1.121 (DEV_CLRn), U1.122 (DEV_OE), U1.128 (VCCIO8), U1.129 (nCONFIG), U1.139 (VCCIO8), U1.144 (VCC_ONE)
/3V3C: C3.2, C31.1, C32.1, C33.1, C34.1, L3.1, U1.2 (VCC_A6), U1.5 (VCC_A3), U1.34 (VCCA2), U1.35 (VCCA1), U1.71 (VCCA5), U1.107 (VCCA3), U1.143 (VCCA4)
/3V3D: C4.2, L4.1, R10.1, R11.1, R15.1, U2.29 (DVDD_3V)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, IC1.10 (GND), IC1.19 (OE), IC2.10 (GND), IC2.19 (OE), IC3.10 (GND), IC3.19 (OE), IC4.10 (GND), IC4.19 (OE), IC5.2 (GND), IC6.2 (GND), P2.2, P3.2, P3.10, P4.2 (TMDS_D2S), P4.5 (TMDS_D1S), P4.8 (TMDS_D0S), P4.11 (TMDS_CLKS), P4.17 (GND), P4.SHLD, P5.3, R1.1, R2.2, R8.1, R9.2, R12.2, R16.1, R18.2, R20.2, U1.3 (GND), U1.4 (GND), U1.42 (GND), U1.53 (GND), U1.63 (GND), U1.68 (GND), U1.83 (GND), U1.95 (GND), U1.104 (GND)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
unnamed: C6.1, L1.2, L2.2, L3.2, L4.2, L8.1, R17.2
unnamed: C9.1, L5.2, L6.2, L7.2, L9.1, R19.2
unnamed: D1.1 (K), R1.2
unnamed: D1.2 (A), P5.2, U1.6 (IO_1A)
unnamed: D2.1 (K), R16.2
unnamed: D2.2 (A), P5.1, U1.7 (IO_1A)
unnamed: F1.2, P2.1
unnamed: IC1.2 (A1), P1.32
unnamed: IC1.3 (A2), P1.31
unnamed: IC1.4 (A3), P1.30
unnamed: IC1.5 (A4), P1.29
unnamed: IC1.6 (A5), P1.28
unnamed: IC1.7 (A6), P1.27
unnamed: IC1.8 (A7), P1.26
unnamed: IC1.9 (A8), P1.25
unnamed: IC1.11 (B8), U1.38 (IO_3)
unnamed: IC1.12 (B7), U1.33 (IO_2/PLL_L_CLKOUTp_)
unnamed: IC1.13 (B6), U1.32 (IO_2/PLL_L_CLKOUTn)
unnamed: IC1.14 (B5), U1.30 (IO_2)
unnamed: IC1.15 (B4), U1.29 (IO_2/CLK1p)
unnamed: IC1.16 (B3), U1.28 (IO_2/CLK1n)
unnamed: IC1.17 (B2), U1.27 (IO_2/CLK0p)
unnamed: IC1.18 (B1), U1.24 (IO_1B)
unnamed: IC2.2 (A1), P1.24
unnamed: IC2.3 (A2), P1.23
unnamed: IC2.4 (A3), P1.22
unnamed: IC2.5 (A4), P1.21
unnamed: IC2.6 (A5), P1.20
unnamed: IC2.7 (A6), P1.19
unnamed: IC2.8 (A7), P1.18
unnamed: IC2.9 (A8), P1.17
unnamed: IC2.11 (B8), U1.48 (IO_3)
unnamed: IC2.12 (B7), U1.47 (IO_3)
unnamed: IC2.13 (B6), U1.46 (IO_3)
unnamed: IC2.14 (B5), U1.45 (IO_3)
unnamed: IC2.15 (B4), U1.44 (IO_3)
unnamed: IC2.16 (B3), U1.43 (IO_3)
unnamed: IC2.17 (B2), U1.41 (IO_3)
unnamed: IC2.18 (B1), U1.39 (IO_3)
unnamed: IC3.2 (A1), P1.16
unnamed: IC3.3 (A2), P1.15
unnamed: IC3.4 (A3), P1.14
unnamed: IC3.5 (A4), P1.13
unnamed: IC3.6 (A5), P1.12
unnamed: IC3.7 (A6), P1.11
unnamed: IC3.8 (A7), P1.10
unnamed: IC3.9 (A8), P1.9
unnamed: IC3.11 (B8), U1.59 (IO_3)
unnamed: IC3.12 (B7), U1.58 (IO_3)
unnamed: IC3.13 (B6), U1.57 (IO_3)
unnamed: IC3.14 (B5), U1.56 (IO_3)
unnamed: IC3.15 (B4), U1.55 (IO_3)
unnamed: IC3.16 (B3), U1.54 (IO_3)
unnamed: IC3.17 (B2), U1.52 (IO_3)
unnamed: IC3.18 (B1), U1.50 (IO_3)
unnamed: IC4.2 (A1), P1.8
unnamed: IC4.3 (A2), P1.7
unnamed: IC4.4 (A3), P1.6
unnamed: IC4.5 (A4), P1.5
unnamed: IC4.6 (A5), P1.4
unnamed: IC4.7 (A6), P1.3
unnamed: IC4.8 (A7), P1.2
unnamed: IC4.9 (A8), P1.1
unnamed: IC4.11 (B8), U1.70 (IO_4)
unnamed: IC4.12 (B7), U1.69 (IO_4)
unnamed: IC4.13 (B6), U1.66 (IO_4)
unnamed: IC4.14 (B5), U1.65 (IO_4)
unnamed: IC4.15 (B4), U1.64 (IO_4)
unnamed: IC4.16 (B3), U1.62 (IO_4)
unnamed: IC4.17 (B2), U1.61 (IO_4)
unnamed: IC4.18 (B1), U1.60 (IO_3)
unnamed: IC5.3 (LX), L8.2
unnamed: IC5.5 (FB), R17.1, R18.1
unnamed: IC6.3 (LX), L9.2
unnamed: IC6.5 (FB), R19.1, R20.1
unnamed: P3.1, R2.1, U1.18 (TCK)
unnamed: P3.3, U1.20 (TDO)
unnamed: P3.5, R4.1, U1.16 (TMS)
unnamed: P3.9, R3.1, U1.19 (TDI)
unnamed: P4.1 (TMDS_D2+), U2.27 (TX2+)
unnamed: P4.3 (TMDS_D2-), U2.26 (TX2-)
unnamed: P4.4 (TMDS_D1+), U2.24 (TX1+)
unnamed: P4.6 (TMDS_D1-), U2.23 (TX1-)
unnamed: P4.7 (TMDS_D0+), U2.21 (TX0+)
unnamed: P4.9 (TMDS_D0-), U2.20 (TX0-)
unnamed: P4.10 (TMDS_CLK+), U2.18 (TXC+)
unnamed: P4.12 (TMDS_CLK-), U2.17 (TXC-)
unnamed: P4.15 (DDC_CLK), R14.2, U2.33 (DDCSCL)
unnamed: P4.16 (DDC_DAT), R13.2, U2.34 (DDCSDA)
unnamed: P4.19 (HPDET), R12.1, U2.16 (HPD)
unnamed: R5.1, U1.15 (JTAGEN)
unnamed: R6.2, U1.138 (CONF_DONE)
unnamed: R7.2, U1.136 (nSTATUS)
unnamed: R8.2, U1.126 (CONFIG_SEL)
unnamed: R9.1, U2.14 (R_EXT)
unnamed: R10.2, U1.113 (IO_7), U2.35 (SCL)
unnamed: R11.2, U1.112 (IO_7), U2.36 (SDA)
unnamed: R15.2, U1.114 (IO_7), U2.28 (INT)
unnamed: U1.26 (IO_2/CLK0n), U3.3 (OUT)
unnamed: U1.74 (IO_5), U2.3 (SPDIF)
unnamed: U1.75 (IO_5), U2.2 (VSYNC)
unnamed: U1.76 (IO_5), U2.64 (HSYNC)
unnamed: U1.77 (IO_5), U2.63 (DE)
unnamed: U1.78 (IO_5), U2.62 (D0)
unnamed: U1.79 (IO_5), U2.61 (D1)
unnamed: U1.80 (IO_5), U2.60 (D2)
unnamed: U1.81 (IO_5), U2.59 (D3)
unnamed: U1.84 (IO_5), U2.58 (D4)
unnamed: U1.85 (IO_5), U2.57 (D5)
unnamed: U1.86 (IO_5), U2.56 (D6)
unnamed: U1.87 (IO_5), U2.55 (D7)
unnamed: U1.88 (IO_6/CLK2p), U2.54 (D8)
unnamed: U1.89 (IO_6/CLK2n), U2.53 (CLK)
unnamed: U1.90 (IO_6/CLK3p), U2.52 (D9)
unnamed: U1.91 (IO_6/CLK3n), U2.50 (D10)
unnamed: U1.92 (IO_6), U2.49 (D11)
unnamed: U1.93 (IO_6), U2.48 (D12)
unnamed: U1.96 (IO_6/DPCLK3), U2.47 (D13)
unnamed: U1.97 (IO_6), U2.46 (D14)
unnamed: U1.98 (IO_6/DPCLK2), U2.45 (D15)
unnamed: U1.99 (IO_6), U2.44 (D16)
unnamed: U1.100 (IO_6), U2.43 (D17)
unnamed: U1.101 (IO_6), U2.42 (D18)
unnamed: U1.102 (IO_6), U2.41 (D19)
unnamed: U1.105 (IO_6), U2.40 (D20)
unnamed: U1.106 (IO_6), U2.39 (D21)
unnamed: U1.110 (IO_7), U2.38 (D22)
unnamed: U1.111 (IO_7), U2.37 (D23)

Board: 2 copper layers, 66.0 x 48.3 mm, 89 parts (38 on the bottom side), 137 nets.

## KiCad design c64mod/c64mod.kicad_pcb

Board: 4 copper layers, 98.4 x 31.8 mm, 21 parts (0 on the bottom side), 46 nets.

Parts:
C1: 22µ; C_1210_HandSoldering
C2, C3, C4, C5, C6, C7, C8: 100n; C_0805_HandSoldering
IC1, IC2: TLC5540; SOIC-24
IC3: AHCT125; SOIC-14_3.9x8.7mm_Pitch1.27mm
IC4, IC5: LVC245A; SOIC-20W_7.5x12.8mm_Pitch1.27mm
P1_1, P1_2, P1_3: CONN_02X02; Pin_Header_Straight_2x02_Pitch2.54mm
P2: CONN_02X13; Pin_Header_Angled_2x13_Pitch2.54mm
R1, R2, R3: 330; R_0805_HandSoldering
U1: L78L33; SOT89-3_Housing_Handsoldering

Connections:
+5V: C1.1, C2.1, C5.1, C6.1, C7.1, C8.1, IC1.11, IC1.13, IC1.14, IC1.15, IC1.16, IC1.17, IC1.18, IC2.11, IC2.13, IC2.14, IC2.15, IC2.16, IC2.17, IC2.18, IC3.14, P1_1.2, R1.1, U1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, IC1.1, IC1.2, IC1.20, IC1.21, IC1.22, IC1.23, IC1.24, IC2.1, IC2.2, IC2.20, IC2.21, IC2.22, IC2.23, IC2.24, IC3.1, IC3.4, IC3.7, IC3.10, IC3.13, IC4.10, IC4.19, IC5.10, IC5.19, P1_3.3, P2.1, P2.26, R3.1, U1.2
unnamed: C3.1, C4.1, IC4.1, IC4.20, IC5.1, IC5.20, U1.1
unnamed: IC1.3, IC4.9
unnamed: IC1.4, IC4.8
unnamed: IC1.5, IC4.7
unnamed: IC1.6, IC4.6
unnamed: IC1.7, IC4.5
unnamed: IC1.8, IC4.4
unnamed: IC1.9, IC4.3
unnamed: IC1.10, IC4.2
unnamed: IC1.12, IC3.11
unnamed: IC1.19, R2.1, R3.2
unnamed: IC2.3, IC5.9
unnamed: IC2.4, IC5.8
unnamed: IC2.5, IC5.7
unnamed: IC2.6, IC5.6
unnamed: IC2.7, IC5.5
unnamed: IC2.8, IC5.4
unnamed: IC2.9, IC5.3
unnamed: IC2.10, IC5.2
unnamed: IC2.12, IC3.8
unnamed: IC2.19, P1_2.3, R1.2
unnamed: IC3.2, P2.14
unnamed: IC3.3, P1_3.2
unnamed: IC3.5, P2.16
unnamed: IC3.6, P1_3.4
unnamed: IC3.9, P2.13
unnamed: IC3.12, P2.11
unnamed: IC4.11, P2.9
unnamed: IC4.12, P2.7
unnamed: IC4.13, P2.5
unnamed: IC4.14, P2.3
unnamed: IC4.15, P2.4
unnamed: IC4.16, P2.6
unnamed: IC4.17, P2.8
unnamed: IC4.18, P2.10
unnamed: IC5.11, P2.18
unnamed: IC5.12, P2.20
unnamed: IC5.13, P2.22
unnamed: IC5.14, P2.24
unnamed: IC5.15, P2.23
unnamed: IC5.16, P2.21
unnamed: IC5.17, P2.19
unnamed: IC5.18, P2.17
unnamed: P1_2.1, R2.2
